# Keil uVision project ble_proxr.uvprojx, settings and files
target ble_proxr Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: QN9080A NXP
  pack: Keil.QN908x_DFP.1.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: ble_proxr.out
  AfterMake: fromelf --bin --output ./output/ble_proxr.bin ./debug/ble_proxr.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CFG_BLE_PRJ, CPU_QN908X, CFG_WM_SOC
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..;../../../../../devices/QN908X/utilities;../../../../../CMSIS/Include;../../../../../devices;../../../../../devices/QN908X;../../../../../devices/QN908X/drivers;../../..;../../../../../middleware/ble/modules/app/api;../../../../../middleware/ble/ip/ble/hl/inc;../inc;../../../../../middleware/ble/ip;../../../../../middleware/ble/ip/ahi/api;../../../../../middleware/ble/ip/ahi/src;../../../../../middleware/ble/ip/ble/hl/api;../../../../../middleware/ble/ip/ble/hl/src/gap;../../../../../middleware/ble/ip/ble/hl/src/gap/gapc;../../../../../middleware/ble/ip/ble/hl/src/gap/gapm;../../../../../middleware/ble/ip/ble/hl/src/gap/smpc;../../../../../middleware/ble/ip/ble/hl/src/gap/smpm;../../../../../middleware/ble/ip/ble/hl/src/gatt;../../../../../middleware/ble/ip/ble/hl/src/gatt/attc;../../../../../middleware/ble/ip/ble/hl/src/gatt/attm;../../../../../middleware/ble/ip/ble/hl/src/gatt/atts;../../../../../middleware/ble/ip/ble/hl/src/gatt/gattc;../../../../../middleware/ble/ip/ble/hl/src/gatt/gattm;../../../../../middleware/ble/ip/ble/hl/src/l2c/l2cc;../../../../../middleware/ble/ip/ble/hl/src/l2c/l2cm;../../../../../middleware/ble/ip/ble/hl/src/prf;../../../../../middleware/ble/ip/ble/hl/src/rwble_hl;../../../../../middleware/ble/ip/ble/ll/src/em;../../../../../middleware/ble/ip/ble/ll/src/llc;../../../../../middleware/ble/ip/ble/ll/src/lld;../../../../../middleware/ble/ip/ble/ll/src/llm;../../../../../middleware/ble/ip/ble/ll/src/rwble;../../../../../middleware/ble/ip/ea/api;../../../../../middleware/ble/ip/em/api;../../../../../middleware/ble/ip/hci/api;../../../../../middleware/ble/ip/hci/src;../../../../../middleware/ble/ip/reg;../../../../../middleware/ble/modules/common/api;../../../../../middleware/ble/modules/dbg/api;../../../../../middleware/ble/modules/display/api;../../../../../middleware/ble/modules/display/src;../../../../../middleware/ble/modules/ecc_p256/api;../../../../../middleware/ble/modules/h4tl/api;../../../../../middleware/ble/modules/ke/api;../../../../../middleware/ble/modules/ke/src;../../../../../middleware/ble/modules/nvds/api;../../../../../middleware/ble/modules/rf/api;../../../../../middleware/ble/modules/rwip/api;../../../../../middleware/ble/libs;../../../../../middleware/ble/modules/app/src;../../../../../middleware/ble/ip/ble/profiles;../../../../../middleware/ble/ip/ble/profiles/anp;../../../../../middleware/ble/ip/ble/profiles/anp/anpc/api;../../../../../middleware/ble/ip/ble/profiles/anp/anpc/src;../../../../../middleware/ble/ip/ble/profiles/anp/anps/api;../../../../../middleware/ble/ip/ble/profiles/anp/anps/src;../../../../../middleware/ble/ip/ble/profiles/bas/basc/api;../../../../../middleware/ble/ip/ble/profiles/bas/basc/src;../../../../../middleware/ble/ip/ble/profiles/bas/bass/api;../../../../../middleware/ble/ip/ble/profiles/bas/bass/src;../../../../../middleware/ble/ip/ble/profiles/blp;../../../../../middleware/ble/ip/ble/profiles/blp/blpc/api;../../../../../middleware/ble/ip/ble/profiles/blp/blpc/src;../../../../../middleware/ble/ip/ble/profiles/blp/blps/api;../../../../../middleware/ble/ip/ble/profiles/blp/blps/src;../../../../../middleware/ble/ip/ble/profiles/cpp;../../../../../middleware/ble/ip/ble/profiles/cpp/cppc/api;../../../../../middleware/ble/ip/ble/profiles/cpp/cppc/src;../../../../../middleware/ble/ip/ble/profiles/cpp/cpps/api;../../../../../middleware/ble/ip/ble/profiles/cpp/cpps/src;../../../../../middleware/ble/ip/ble/profiles/cscp;../../../../../middleware/ble/ip/ble/profiles/cscp/cscpc/api;../../../../../middleware/ble/ip/ble/profiles/cscp/cscpc/src;../../../../../middleware/ble/ip/ble/profiles/cscp/cscps/api;../../../../../middleware/ble/ip/ble/profiles/cscp/cscps/src;../../../../../middleware/ble/ip/ble/profiles/dis/disc/api;../../../../../middleware/ble/ip/ble/profiles/dis/disc/src;../../../../../middleware/ble/ip/ble/profiles/dis/diss/api;../../../../../middleware/ble/ip/ble/profiles/dis/diss/src;../../../../../middleware/ble/ip/ble/profiles/find;../../../../../middleware/ble/ip/ble/profiles/find/findl/api;../../../../../middleware/ble/ip/ble/profiles/find/findl/src;../../../../../middleware/ble/ip/ble/profiles/find/findt/api;../../../../../middleware/ble/ip/ble/profiles/find/findt/src;../../../../../middleware/ble/ip/ble/profiles/glp;../../../../../middleware/ble/ip/ble/profiles/glp/glpc/api;../../../../../middleware/ble/ip/ble/profiles/glp/glpc/src;../../../../../middleware/ble/ip/ble/profiles/glp/glps/api;../../../../../middleware/ble/ip/ble/profiles/glp/glps/src;../../../../../middleware/ble/ip/ble/profiles/hogp;../../../../../middleware/ble/ip/ble/profiles/hogp/hogpbh/api;../../../../../middleware/ble/ip/ble/profiles/hogp/hogpbh/src;../../../../../middleware/ble/ip/ble/profiles/hogp/hogpd/api;../../../../../middleware/ble/ip/ble/profiles/hogp/hogpd/src;../../../../../middleware/ble/ip/ble/profiles/hogp/hogprh/api;../../../../../middleware/ble/ip/ble/profiles/hogp/hogprh/src;../../../../../middleware/ble/ip/ble/profiles/hrp;../../../../../middleware/ble/ip/ble/profiles/hrp/hrpc/api;../../../../../middleware/ble/ip/ble/profiles/hrp/hrpc/src;../../../../../middleware/ble/ip/ble/profiles/hrp/hrps/api;../../../../../middleware/ble/ip/ble/profiles/hrp/hrps/src;../../../../../middleware/ble/ip/ble/profiles/htp;../../../../../middleware/ble/ip/ble/profiles/htp/htpc/api;../../../../../middleware/ble/ip/ble/profiles/htp/htpc/src;../../../../../middleware/ble/ip/ble/profiles/htp/htpt/api;../../../../../middleware/ble/ip/ble/profiles/htp/htpt/src;../../../../../middleware/ble/ip/ble/profiles/lan;../../../../../middleware/ble/ip/ble/profiles/lan/lanc/api;../../../../../middleware/ble/ip/ble/profiles/lan/lanc/src;../../../../../middleware/ble/ip/ble/profiles/lan/lans/api;../../../../../middleware/ble/ip/ble/profiles/lan/lans/src;../../../../../middleware/ble/ip/ble/profiles/pasp;../../../../../middleware/ble/ip/ble/profiles/pasp/paspc/api;../../../../../middleware/ble/ip/ble/profiles/pasp/paspc/src;../../../../../middleware/ble/ip/ble/profiles/pasp/pasps/api;../../../../../middleware/ble/ip/ble/profiles/pasp/pasps/src;../../../../../middleware/ble/ip/ble/profiles/prox/proxm/api;../../../../../middleware/ble/ip/ble/profiles/prox/proxm/src;../../../../../middleware/ble/ip/ble/profiles/prox/proxr/api;../../../../../middleware/ble/ip/ble/profiles/prox/proxr/src;../../../../../middleware/ble/ip/ble/profiles/qpp;../../../../../middleware/ble/ip/ble/profiles/qpp/qppc/api;../../../../../middleware/ble/ip/ble/profiles/qpp/qppc/src;../../../../../middleware/ble/ip/ble/profiles/qpp/qpps/api;../../../../../middleware/ble/ip/ble/profiles/qpp/qpps/src;../../../../../middleware/ble/ip/ble/profiles/rscp;../../../../../middleware/ble/ip/ble/profiles/rscp/rscpc/api;../../../../../middleware/ble/ip/ble/profiles/rscp/rscpc/src;../../../../../middleware/ble/ip/ble/profiles/rscp/rscps/api;../../../../../middleware/ble/ip/ble/profiles/rscp/rscps/src;../../../../../middleware/ble/ip/ble/profiles/scpp;../../../../../middleware/ble/ip/ble/profiles/scpp/scppc/api;../../../../../middleware/ble/ip/ble/profiles/scpp/scppc/src;../../../../../middleware/ble/ip/ble/profiles/scpp/scpps/api;../../../../../middleware/ble/ip/ble/profiles/scpp/scpps/src;../../../../../middleware/ble/ip/ble/profiles/tip;../../../../../middleware/ble/ip/ble/profiles/tip/tipc/api;../../../../../middleware/ble/ip/ble/profiles/tip/tipc/src;../../../../../middleware/ble/ip/ble/profiles/tip/tips/api;../../../../../middleware/ble/ip/ble/profiles/tip/tips/src;../../../../../middleware/ble/ip/ble/profiles/yell;../../../../../middleware/ble/ip/ble/profiles/yell/yells/api;../../../../../middleware/ble/ip/ble/profiles/yell/yells/src;../../../../../middleware/ble/modules/timer_manager/api;../../../../../middleware/ble/modules/power_manager/api;../../../../../middleware/ble/modules/eif_adapter/api;../../../../../middleware/ble/modules/eif_adapter/src/uart_adapter;../../../../../middleware/ble/modules/eif_adapter/src/usb_vcom_adapter;../../../../../middleware/usb_1.0.2;../../../../../middleware/usb_1.0.2/include;../../../../../middleware/usb_1.0.2/device;../../../../../middleware/usb_1.0.2/osa;../../../../../middleware/usb_1.0.2/device/class;.\Accel;.\Alg;.\Tap
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x4000400 size 0xfc00
  scatter file: QN908X.scf
  link misc: --remove 
--symdefs 
= 
../../../../../devices/QN908X/arm/fw_symbols_keil.txt
  group startup
    ../../../../../devices/QN908X/arm/: startup_QN908X.s
    ../../../../../devices/QN908X/: system_QN908X.c system_QN908X.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/QN908X/drivers/: fsl_gpio.h fsl_gpio.c fsl_ctimer.h fsl_ctimer.c fsl_flash.h fsl_flash.c fsl_rf.h fsl_rf.c fsl_rtc.h fsl_rtc.c fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_reset.h fsl_reset.c fsl_power.h fsl_power.c fsl_power_in_ram.s fsl_calibration.h fsl_calibration.c fsl_iocon.h fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_spi.c fsl_spi_dma.c fsl_dma.c
  group app
    ../../../../../middleware/ble/modules/app/src/: app_ble.c app_ble_task.c app_gap.c app_gatt.c app_bass.c app_proxr.c
    ../../../../../middleware/ble/modules/app/api/: app_ble.h app_ble_task.h app_gap.h app_gatt.h app_bass.h app_proxr.h
  group profile
    ../../../../../middleware/ble/ip/ble/hl/src/prf/: prf.c prf_utils.c
    ../../../../../middleware/ble/ip/ble/hl/inc/: prf.h prf_utils.h rwprf_config.h
    ../../../../../middleware/ble/ip/ble/hl/api/: prf_types.h
    ../../../../../middleware/ble/ip/ble/profiles/bas/bass/src/: bass.c bass.h bass_task.c
    ../../../../../middleware/ble/ip/ble/profiles/bas/bass/api/: bass_task.h
    ../../../../../middleware/ble/ip/ble/profiles/prox/proxr/src/: proxr.c proxr.h proxr_task.c
    ../../../../../middleware/ble/ip/ble/profiles/prox/proxr/api/: proxr_task.h
  group board
    ../: board.c board.h pin_mux.c pin_mux.h button.c button.h led.c led.h battery.h battery.c clock_config.c clock_config.h
  group main
    ../: main.c ble_config.h profile_config.h system_config.h
  group ble_stack
    ../../../../../middleware/ble/libs/: qnble.c
    ../../../../../middleware/ble/modules/dbg/src/: dbg_assert.c
    ../../../../../middleware/ble/libs/arm/: lib_ble_stack.lib
  group timer_manager
    ../../../../../middleware/ble/modules/timer_manager/api/: timer_adapter.h timer_manager.h
    ../../../../../middleware/ble/modules/timer_manager/src/: timer_adapter.c timer_manager.c
  group power_manager
    ../../../../../middleware/ble/modules/power_manager/api/: power_manager.h
    ../../../../../middleware/ble/modules/power_manager/src/: power_manager.c
  group eif_adapter
    ../../../../../middleware/ble/modules/eif_adapter/api/: eif_adapter.h
    ../../../../../middleware/ble/modules/eif_adapter/src/: eif_adapter.c
    ../../../../../middleware/ble/modules/eif_adapter/src/uart_adapter/: uart_adapter.h uart_adapter.c
  group utilities
    ../../../../../devices/QN908X/utilities/: fsl_debug_console.c fsl_debug_console.h
  group Accel
    ./Accel/: accel_spi.c ADXL362.c adxl362_spi.c spi_for_accel.c
  group Alg
    ./Alg/: AccelBuffer.c adxl362_accel.c AlgExec.c DownSample.c GoalTracking.c stats.c StepCount.c StepPointCounter.c
  group Tap
    ./Tap/: TapDetection.c TapHandler.c TapQualifier.c TapSampleBuffer.c TapStateProfiler.c
target ble_proxr Release (ARM-ADS)
  device: QN9080A NXP
  pack: Keil.QN908x_DFP.1.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: ble_proxr.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CFG_BLE_PRJ, CPU_QN908X, CFG_WM_SOC
  c misc: as above
  c include: ..;../../../../../devices/QN908X/utilities;../../../../../CMSIS/Include;../../../../../devices;../../../../../devices/QN908X;../../../../../devices/QN908X/drivers;../../..;../../../../../middleware/ble/modules/app/api;../../../../../middleware/ble/ip/ble/hl/inc;../inc;../../../../../middleware/ble/ip;../../../../../middleware/ble/ip/ahi/api;../../../../../middleware/ble/ip/ahi/src;../../../../../middleware/ble/ip/ble/hl/api;../../../../../middleware/ble/ip/ble/hl/src/gap;../../../../../middleware/ble/ip/ble/hl/src/gap/gapc;../../../../../middleware/ble/ip/ble/hl/src/gap/gapm;../../../../../middleware/ble/ip/ble/hl/src/gap/smpc;../../../../../middleware/ble/ip/ble/hl/src/gap/smpm;../../../../../middleware/ble/ip/ble/hl/src/gatt;../../../../../middleware/ble/ip/ble/hl/src/gatt/attc;../../../../../middleware/ble/ip/ble/hl/src/gatt/attm;../../../../../middleware/ble/ip/ble/hl/src/gatt/atts;../../../../../middleware/ble/ip/ble/hl/src/gatt/gattc;../../../../../middleware/ble/ip/ble/hl/src/gatt/gattm;../../../../../middleware/ble/ip/ble/hl/src/l2c/l2cc;../../../../../middleware/ble/ip/ble/hl/src/l2c/l2cm;../../../../../middleware/ble/ip/ble/hl/src/prf;../../../../../middleware/ble/ip/ble/hl/src/rwble_hl;../../../../../middleware/ble/ip/ble/ll/src/em;../../../../../middleware/ble/ip/ble/ll/src/llc;../../../../../middleware/ble/ip/ble/ll/src/lld;../../../../../middleware/ble/ip/ble/ll/src/llm;../../../../../middleware/ble/ip/ble/ll/src/rwble;../../../../../middleware/ble/ip/ea/api;../../../../../middleware/ble/ip/em/api;../../../../../middleware/ble/ip/hci/api;../../../../../middleware/ble/ip/hci/src;../../../../../middleware/ble/ip/reg;../../../../../middleware/ble/modules/common/api;../../../../../middleware/ble/modules/dbg/api;../../../../../middleware/ble/modules/display/api;../../../../../middleware/ble/modules/display/src;../../../../../middleware/ble/modules/ecc_p256/api;../../../../../middleware/ble/modules/h4tl/api;../../../../../middleware/ble/modules/ke/api;../../../../../middleware/ble/modules/ke/src;../../../../../middleware/ble/modules/nvds/api;../../../../../middleware/ble/modules/rf/api;../../../../../middleware/ble/modules/rwip/api;../../../../../middleware/ble/libs;../../../../../middleware/ble/modules/app/src;../../../../../middleware/ble/ip/ble/profiles;../../../../../middleware/ble/ip/ble/profiles/anp;../../../../../middleware/ble/ip/ble/profiles/anp/anpc/api;../../../../../middleware/ble/ip/ble/profiles/anp/anpc/src;../../../../../middleware/ble/ip/ble/profiles/anp/anps/api;../../../../../middleware/ble/ip/ble/profiles/anp/anps/src;../../../../../middleware/ble/ip/ble/profiles/bas/basc/api;../../../../../middleware/ble/ip/ble/profiles/bas/basc/src;../../../../../middleware/ble/ip/ble/profiles/bas/bass/api;../../../../../middleware/ble/ip/ble/profiles/bas/bass/src;../../../../../middleware/ble/ip/ble/profiles/blp;../../../../../middleware/ble/ip/ble/profiles/blp/blpc/api;../../../../../middleware/ble/ip/ble/profiles/blp/blpc/src;../../../../../middleware/ble/ip/ble/profiles/blp/blps/api;../../../../../middleware/ble/ip/ble/profiles/blp/blps/src;../../../../../middleware/ble/ip/ble/profiles/cpp;../../../../../middleware/ble/ip/ble/profiles/cpp/cppc/api;../../../../../middleware/ble/ip/ble/profiles/cpp/cppc/src;../../../../../middleware/ble/ip/ble/profiles/cpp/cpps/api;../../../../../middleware/ble/ip/ble/profiles/cpp/cpps/src;../../../../../middleware/ble/ip/ble/profiles/cscp;../../../../../middleware/ble/ip/ble/profiles/cscp/cscpc/api;../../../../../middleware/ble/ip/ble/profiles/cscp/cscpc/src;../../../../../middleware/ble/ip/ble/profiles/cscp/cscps/api;../../../../../middleware/ble/ip/ble/profiles/cscp/cscps/src;../../../../../middleware/ble/ip/ble/profiles/dis/disc/api;../../../../../middleware/ble/ip/ble/profiles/dis/disc/src;../../../../../middleware/ble/ip/ble/profiles/dis/diss/api;../../../../../middleware/ble/ip/ble/profiles/dis/diss/src;../../../../../middleware/ble/ip/ble/profiles/find;../../../../../middleware/ble/ip/ble/profiles/find/findl/api;../../../../../middleware/ble/ip/ble/profiles/find/findl/src;../../../../../middleware/ble/ip/ble/profiles/find/findt/api;../../../../../middleware/ble/ip/ble/profiles/find/findt/src;../../../../../middleware/ble/ip/ble/profiles/glp;../../../../../middleware/ble/ip/ble/profiles/glp/glpc/api;../../../../../middleware/ble/ip/ble/profiles/glp/glpc/src;../../../../../middleware/ble/ip/ble/profiles/glp/glps/api;../../../../../middleware/ble/ip/ble/profiles/glp/glps/src;../../../../../middleware/ble/ip/ble/profiles/hogp;../../../../../middleware/ble/ip/ble/profiles/hogp/hogpbh/api;../../../../../middleware/ble/ip/ble/profiles/hogp/hogpbh/src;../../../../../middleware/ble/ip/ble/profiles/hogp/hogpd/api;../../../../../middleware/ble/ip/ble/profiles/hogp/hogpd/src;../../../../../middleware/ble/ip/ble/profiles/hogp/hogprh/api;../../../../../middleware/ble/ip/ble/profiles/hogp/hogprh/src;../../../../../middleware/ble/ip/ble/profiles/hrp;../../../../../middleware/ble/ip/ble/profiles/hrp/hrpc/api;../../../../../middleware/ble/ip/ble/profiles/hrp/hrpc/src;../../../../../middleware/ble/ip/ble/profiles/hrp/hrps/api;../../../../../middleware/ble/ip/ble/profiles/hrp/hrps/src;../../../../../middleware/ble/ip/ble/profiles/htp;../../../../../middleware/ble/ip/ble/profiles/htp/htpc/api;../../../../../middleware/ble/ip/ble/profiles/htp/htpc/src;../../../../../middleware/ble/ip/ble/profiles/htp/htpt/api;../../../../../middleware/ble/ip/ble/profiles/htp/htpt/src;../../../../../middleware/ble/ip/ble/profiles/lan;../../../../../middleware/ble/ip/ble/profiles/lan/lanc/api;../../../../../middleware/ble/ip/ble/profiles/lan/lanc/src;../../../../../middleware/ble/ip/ble/profiles/lan/lans/api;../../../../../middleware/ble/ip/ble/profiles/lan/lans/src;../../../../../middleware/ble/ip/ble/profiles/pasp;../../../../../middleware/ble/ip/ble/profiles/pasp/paspc/api;../../../../../middleware/ble/ip/ble/profiles/pasp/paspc/src;../../../../../middleware/ble/ip/ble/profiles/pasp/pasps/api;../../../../../middleware/ble/ip/ble/profiles/pasp/pasps/src;../../../../../middleware/ble/ip/ble/profiles/prox/proxm/api;../../../../../middleware/ble/ip/ble/profiles/prox/proxm/src;../../../../../middleware/ble/ip/ble/profiles/prox/proxr/api;../../../../../middleware/ble/ip/ble/profiles/prox/proxr/src;../../../../../middleware/ble/ip/ble/profiles/qpp;../../../../../middleware/ble/ip/ble/profiles/qpp/qppc/api;../../../../../middleware/ble/ip/ble/profiles/qpp/qppc/src;../../../../../middleware/ble/ip/ble/profiles/qpp/qpps/api;../../../../../middleware/ble/ip/ble/profiles/qpp/qpps/src;../../../../../middleware/ble/ip/ble/profiles/rscp;../../../../../middleware/ble/ip/ble/profiles/rscp/rscpc/api;../../../../../middleware/ble/ip/ble/profiles/rscp/rscpc/src;../../../../../middleware/ble/ip/ble/profiles/rscp/rscps/api;../../../../../middleware/ble/ip/ble/profiles/rscp/rscps/src;../../../../../middleware/ble/ip/ble/profiles/scpp;../../../../../middleware/ble/ip/ble/profiles/scpp/scppc/api;../../../../../middleware/ble/ip/ble/profiles/scpp/scppc/src;../../../../../middleware/ble/ip/ble/profiles/scpp/scpps/api;../../../../../middleware/ble/ip/ble/profiles/scpp/scpps/src;../../../../../middleware/ble/ip/ble/profiles/tip;../../../../../middleware/ble/ip/ble/profiles/tip/tipc/api;../../../../../middleware/ble/ip/ble/profiles/tip/tipc/src;../../../../../middleware/ble/ip/ble/profiles/tip/tips/api;../../../../../middleware/ble/ip/ble/profiles/tip/tips/src;../../../../../middleware/ble/ip/ble/profiles/yell;../../../../../middleware/ble/ip/ble/profiles/yell/yells/api;../../../../../middleware/ble/ip/ble/profiles/yell/yells/src;../../../../../middleware/ble/modules/timer_manager/api;../../../../../middleware/ble/modules/power_manager/api;../../../../../middleware/ble/modules/eif_adapter/api;../../../../../middleware/ble/modules/eif_adapter/src/uart_adapter;../../../../../middleware/ble/modules/eif_adapter/src/usb_vcom_adapter;../../../../../middleware/usb_1.0.2;../../../../../middleware/usb_1.0.2/include;../../../../../middleware/usb_1.0.2/device;../../../../../middleware/usb_1.0.2/osa;../../../../../middleware/usb_1.0.2/device/class
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  scatter file: QN908X.scf
  link misc: as above
